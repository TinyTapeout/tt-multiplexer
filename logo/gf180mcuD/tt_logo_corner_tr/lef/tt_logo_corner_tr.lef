VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO tt_logo_corner_tr
  CLASS BLOCK ;
  FOREIGN tt_logo_corner_tr ;
  ORIGIN 0.000 0.000 ;
  SIZE 220.000 BY 220.000 ;
  OBS
      LAYER Metal1 ;
        RECT 27.000 144.000 213.000 217.000 ;
        RECT 28.000 143.000 213.000 144.000 ;
        RECT 29.000 142.000 213.000 143.000 ;
        RECT 30.000 141.000 213.000 142.000 ;
        RECT 31.000 140.000 213.000 141.000 ;
        RECT 32.000 139.000 213.000 140.000 ;
        RECT 33.000 138.000 213.000 139.000 ;
        RECT 34.000 137.000 213.000 138.000 ;
        RECT 35.000 136.000 213.000 137.000 ;
        RECT 36.000 135.000 213.000 136.000 ;
        RECT 37.000 134.000 213.000 135.000 ;
        RECT 38.000 133.000 213.000 134.000 ;
        RECT 39.000 132.000 213.000 133.000 ;
        RECT 40.000 131.000 213.000 132.000 ;
        RECT 41.000 130.000 213.000 131.000 ;
        RECT 42.000 129.000 213.000 130.000 ;
        RECT 43.000 127.000 213.000 129.000 ;
        RECT 44.000 126.000 213.000 127.000 ;
        RECT 45.000 125.000 213.000 126.000 ;
        RECT 46.000 124.000 213.000 125.000 ;
        RECT 47.000 123.000 213.000 124.000 ;
        RECT 48.000 122.000 213.000 123.000 ;
        RECT 49.000 121.000 213.000 122.000 ;
        RECT 50.000 120.000 213.000 121.000 ;
        RECT 51.000 119.000 213.000 120.000 ;
        RECT 52.000 118.000 213.000 119.000 ;
        RECT 53.000 117.000 213.000 118.000 ;
        RECT 54.000 116.000 213.000 117.000 ;
        RECT 55.000 115.000 213.000 116.000 ;
        RECT 56.000 114.000 213.000 115.000 ;
        RECT 57.000 113.000 213.000 114.000 ;
        RECT 58.000 112.000 213.000 113.000 ;
        RECT 59.000 111.000 213.000 112.000 ;
        RECT 60.000 109.000 213.000 111.000 ;
        RECT 61.000 108.000 213.000 109.000 ;
        RECT 62.000 107.000 213.000 108.000 ;
        RECT 63.000 106.000 213.000 107.000 ;
        RECT 64.000 105.000 213.000 106.000 ;
        RECT 65.000 104.000 213.000 105.000 ;
        RECT 66.000 103.000 213.000 104.000 ;
        RECT 67.000 102.000 213.000 103.000 ;
        RECT 68.000 101.000 213.000 102.000 ;
        RECT 69.000 100.000 213.000 101.000 ;
        RECT 70.000 99.000 213.000 100.000 ;
        RECT 71.000 98.000 213.000 99.000 ;
        RECT 72.000 97.000 213.000 98.000 ;
        RECT 73.000 96.000 213.000 97.000 ;
        RECT 74.000 95.000 213.000 96.000 ;
        RECT 75.000 94.000 213.000 95.000 ;
        RECT 76.000 93.000 213.000 94.000 ;
        RECT 77.000 92.000 213.000 93.000 ;
        RECT 78.000 91.000 213.000 92.000 ;
        RECT 79.000 90.000 213.000 91.000 ;
        RECT 80.000 89.000 213.000 90.000 ;
        RECT 81.000 87.000 213.000 89.000 ;
        RECT 82.000 86.000 213.000 87.000 ;
        RECT 83.000 85.000 213.000 86.000 ;
        RECT 84.000 84.000 213.000 85.000 ;
        RECT 85.000 83.000 213.000 84.000 ;
        RECT 86.000 82.000 213.000 83.000 ;
        RECT 87.000 81.000 213.000 82.000 ;
        RECT 88.000 80.000 213.000 81.000 ;
        RECT 89.000 79.000 213.000 80.000 ;
        RECT 90.000 78.000 213.000 79.000 ;
        RECT 91.000 77.000 213.000 78.000 ;
        RECT 92.000 76.000 213.000 77.000 ;
        RECT 93.000 75.000 213.000 76.000 ;
        RECT 94.000 74.000 213.000 75.000 ;
        RECT 95.000 73.000 213.000 74.000 ;
        RECT 96.000 72.000 213.000 73.000 ;
        RECT 97.000 71.000 213.000 72.000 ;
        RECT 98.000 70.000 213.000 71.000 ;
        RECT 99.000 69.000 213.000 70.000 ;
        RECT 100.000 68.000 213.000 69.000 ;
        RECT 101.000 67.000 213.000 68.000 ;
        RECT 102.000 66.000 213.000 67.000 ;
        RECT 103.000 65.000 213.000 66.000 ;
        RECT 104.000 64.000 213.000 65.000 ;
        RECT 105.000 63.000 213.000 64.000 ;
        RECT 106.000 62.000 213.000 63.000 ;
        RECT 107.000 61.000 213.000 62.000 ;
        RECT 108.000 60.000 213.000 61.000 ;
        RECT 109.000 59.000 213.000 60.000 ;
        RECT 110.000 57.000 213.000 59.000 ;
        RECT 111.000 56.000 213.000 57.000 ;
        RECT 112.000 55.000 213.000 56.000 ;
        RECT 113.000 54.000 213.000 55.000 ;
        RECT 114.000 53.000 213.000 54.000 ;
        RECT 115.000 52.000 213.000 53.000 ;
        RECT 116.000 51.000 213.000 52.000 ;
        RECT 117.000 50.000 213.000 51.000 ;
        RECT 118.000 49.000 213.000 50.000 ;
        RECT 119.000 48.000 213.000 49.000 ;
        RECT 120.000 47.000 213.000 48.000 ;
        RECT 121.000 46.000 213.000 47.000 ;
        RECT 122.000 45.000 213.000 46.000 ;
        RECT 123.000 44.000 213.000 45.000 ;
        RECT 124.000 43.000 213.000 44.000 ;
        RECT 125.000 42.000 213.000 43.000 ;
        RECT 126.000 41.000 213.000 42.000 ;
        RECT 127.000 39.000 213.000 41.000 ;
        RECT 128.000 38.000 213.000 39.000 ;
        RECT 129.000 37.000 213.000 38.000 ;
        RECT 130.000 36.000 213.000 37.000 ;
        RECT 131.000 35.000 213.000 36.000 ;
        RECT 132.000 34.000 213.000 35.000 ;
        RECT 133.000 33.000 213.000 34.000 ;
        RECT 134.000 32.000 213.000 33.000 ;
        RECT 135.000 31.000 213.000 32.000 ;
        RECT 136.000 30.000 213.000 31.000 ;
        RECT 137.000 29.000 213.000 30.000 ;
        RECT 138.000 28.000 213.000 29.000 ;
        RECT 139.000 27.000 213.000 28.000 ;
        RECT 140.000 26.000 213.000 27.000 ;
        RECT 141.000 25.000 213.000 26.000 ;
        RECT 142.000 24.000 213.000 25.000 ;
        RECT 143.000 23.000 213.000 24.000 ;
        RECT 144.000 22.000 213.000 23.000 ;
        RECT 145.000 21.000 213.000 22.000 ;
        RECT 146.000 19.000 213.000 21.000 ;
        RECT 147.000 18.000 213.000 19.000 ;
        RECT 148.000 17.000 213.000 18.000 ;
        RECT 149.000 16.000 213.000 17.000 ;
        RECT 150.000 15.000 213.000 16.000 ;
        RECT 151.000 14.000 213.000 15.000 ;
        RECT 153.000 13.000 213.000 14.000 ;
        RECT 154.000 12.000 213.000 13.000 ;
        RECT 155.000 11.000 213.000 12.000 ;
        RECT 156.000 10.000 213.000 11.000 ;
        RECT 157.000 9.000 213.000 10.000 ;
        RECT 158.000 8.000 213.000 9.000 ;
        RECT 159.000 7.000 213.000 8.000 ;
        RECT 160.000 6.000 213.000 7.000 ;
        RECT 161.000 5.000 213.000 6.000 ;
        RECT 162.000 4.495 213.000 5.000 ;
      LAYER Metal2 ;
        RECT 27.000 144.000 213.000 217.000 ;
        RECT 28.000 143.000 213.000 144.000 ;
        RECT 29.000 142.000 213.000 143.000 ;
        RECT 30.000 141.000 213.000 142.000 ;
        RECT 31.000 140.000 213.000 141.000 ;
        RECT 32.000 139.000 213.000 140.000 ;
        RECT 33.000 138.000 213.000 139.000 ;
        RECT 34.000 137.000 213.000 138.000 ;
        RECT 35.000 136.000 213.000 137.000 ;
        RECT 36.000 135.000 213.000 136.000 ;
        RECT 37.000 134.000 213.000 135.000 ;
        RECT 38.000 133.000 213.000 134.000 ;
        RECT 39.000 132.000 213.000 133.000 ;
        RECT 40.000 131.000 213.000 132.000 ;
        RECT 41.000 130.000 213.000 131.000 ;
        RECT 42.000 129.000 213.000 130.000 ;
        RECT 43.000 127.000 213.000 129.000 ;
        RECT 44.000 126.000 213.000 127.000 ;
        RECT 45.000 125.000 213.000 126.000 ;
        RECT 46.000 124.000 213.000 125.000 ;
        RECT 47.000 123.000 213.000 124.000 ;
        RECT 48.000 122.000 213.000 123.000 ;
        RECT 49.000 121.000 213.000 122.000 ;
        RECT 50.000 120.000 213.000 121.000 ;
        RECT 51.000 119.000 213.000 120.000 ;
        RECT 52.000 118.000 213.000 119.000 ;
        RECT 53.000 117.000 213.000 118.000 ;
        RECT 54.000 116.000 213.000 117.000 ;
        RECT 55.000 115.000 213.000 116.000 ;
        RECT 56.000 114.000 213.000 115.000 ;
        RECT 57.000 113.000 213.000 114.000 ;
        RECT 58.000 112.000 213.000 113.000 ;
        RECT 59.000 111.000 213.000 112.000 ;
        RECT 60.000 109.000 213.000 111.000 ;
        RECT 61.000 108.000 213.000 109.000 ;
        RECT 62.000 107.000 213.000 108.000 ;
        RECT 63.000 106.000 213.000 107.000 ;
        RECT 64.000 105.000 213.000 106.000 ;
        RECT 65.000 104.000 213.000 105.000 ;
        RECT 66.000 103.000 213.000 104.000 ;
        RECT 67.000 102.000 213.000 103.000 ;
        RECT 68.000 101.000 213.000 102.000 ;
        RECT 69.000 100.000 213.000 101.000 ;
        RECT 70.000 99.000 213.000 100.000 ;
        RECT 71.000 98.000 213.000 99.000 ;
        RECT 72.000 97.000 213.000 98.000 ;
        RECT 73.000 96.000 213.000 97.000 ;
        RECT 74.000 95.000 213.000 96.000 ;
        RECT 75.000 94.000 213.000 95.000 ;
        RECT 76.000 93.000 213.000 94.000 ;
        RECT 77.000 92.000 213.000 93.000 ;
        RECT 78.000 91.000 213.000 92.000 ;
        RECT 79.000 90.000 213.000 91.000 ;
        RECT 80.000 89.000 213.000 90.000 ;
        RECT 81.000 87.000 213.000 89.000 ;
        RECT 82.000 86.000 213.000 87.000 ;
        RECT 83.000 85.000 213.000 86.000 ;
        RECT 84.000 84.000 213.000 85.000 ;
        RECT 85.000 83.000 213.000 84.000 ;
        RECT 86.000 82.000 213.000 83.000 ;
        RECT 87.000 81.000 213.000 82.000 ;
        RECT 88.000 80.000 213.000 81.000 ;
        RECT 89.000 79.000 213.000 80.000 ;
        RECT 90.000 78.000 213.000 79.000 ;
        RECT 91.000 77.000 213.000 78.000 ;
        RECT 92.000 76.000 213.000 77.000 ;
        RECT 93.000 75.000 213.000 76.000 ;
        RECT 94.000 74.000 213.000 75.000 ;
        RECT 95.000 73.000 213.000 74.000 ;
        RECT 96.000 72.000 213.000 73.000 ;
        RECT 97.000 71.000 213.000 72.000 ;
        RECT 98.000 70.000 213.000 71.000 ;
        RECT 99.000 69.000 213.000 70.000 ;
        RECT 100.000 68.000 213.000 69.000 ;
        RECT 101.000 67.000 213.000 68.000 ;
        RECT 102.000 66.000 213.000 67.000 ;
        RECT 103.000 65.000 213.000 66.000 ;
        RECT 104.000 64.000 213.000 65.000 ;
        RECT 105.000 63.000 213.000 64.000 ;
        RECT 106.000 62.000 213.000 63.000 ;
        RECT 107.000 61.000 213.000 62.000 ;
        RECT 108.000 60.000 213.000 61.000 ;
        RECT 109.000 59.000 213.000 60.000 ;
        RECT 110.000 57.000 213.000 59.000 ;
        RECT 111.000 56.000 213.000 57.000 ;
        RECT 112.000 55.000 213.000 56.000 ;
        RECT 113.000 54.000 213.000 55.000 ;
        RECT 114.000 53.000 213.000 54.000 ;
        RECT 115.000 52.000 213.000 53.000 ;
        RECT 116.000 51.000 213.000 52.000 ;
        RECT 117.000 50.000 213.000 51.000 ;
        RECT 118.000 49.000 213.000 50.000 ;
        RECT 119.000 48.000 213.000 49.000 ;
        RECT 120.000 47.000 213.000 48.000 ;
        RECT 121.000 46.000 213.000 47.000 ;
        RECT 122.000 45.000 213.000 46.000 ;
        RECT 123.000 44.000 213.000 45.000 ;
        RECT 124.000 43.000 213.000 44.000 ;
        RECT 125.000 42.000 213.000 43.000 ;
        RECT 126.000 41.000 213.000 42.000 ;
        RECT 127.000 39.000 213.000 41.000 ;
        RECT 128.000 38.000 213.000 39.000 ;
        RECT 129.000 37.000 213.000 38.000 ;
        RECT 130.000 36.000 213.000 37.000 ;
        RECT 131.000 35.000 213.000 36.000 ;
        RECT 132.000 34.000 213.000 35.000 ;
        RECT 133.000 33.000 213.000 34.000 ;
        RECT 134.000 32.000 213.000 33.000 ;
        RECT 135.000 31.000 213.000 32.000 ;
        RECT 136.000 30.000 213.000 31.000 ;
        RECT 137.000 29.000 213.000 30.000 ;
        RECT 138.000 28.000 213.000 29.000 ;
        RECT 139.000 27.000 213.000 28.000 ;
        RECT 140.000 26.000 213.000 27.000 ;
        RECT 141.000 25.000 213.000 26.000 ;
        RECT 142.000 24.000 213.000 25.000 ;
        RECT 143.000 23.000 213.000 24.000 ;
        RECT 144.000 22.000 213.000 23.000 ;
        RECT 145.000 21.000 213.000 22.000 ;
        RECT 146.000 19.000 213.000 21.000 ;
        RECT 147.000 18.000 213.000 19.000 ;
        RECT 148.000 17.000 213.000 18.000 ;
        RECT 149.000 16.000 213.000 17.000 ;
        RECT 150.000 15.000 213.000 16.000 ;
        RECT 151.000 14.000 213.000 15.000 ;
        RECT 153.000 13.000 213.000 14.000 ;
        RECT 154.000 12.000 213.000 13.000 ;
        RECT 155.000 11.000 213.000 12.000 ;
        RECT 156.000 10.000 213.000 11.000 ;
        RECT 157.000 9.000 213.000 10.000 ;
        RECT 158.000 8.000 213.000 9.000 ;
        RECT 159.000 7.000 213.000 8.000 ;
        RECT 160.000 6.000 213.000 7.000 ;
        RECT 161.000 5.000 213.000 6.000 ;
        RECT 162.000 4.495 213.000 5.000 ;
      LAYER Metal3 ;
        RECT 27.000 144.000 213.000 217.000 ;
        RECT 28.000 143.000 213.000 144.000 ;
        RECT 29.000 142.000 213.000 143.000 ;
        RECT 30.000 141.000 213.000 142.000 ;
        RECT 31.000 140.000 213.000 141.000 ;
        RECT 32.000 139.000 213.000 140.000 ;
        RECT 33.000 138.000 213.000 139.000 ;
        RECT 34.000 137.000 213.000 138.000 ;
        RECT 35.000 136.000 213.000 137.000 ;
        RECT 36.000 135.000 213.000 136.000 ;
        RECT 37.000 134.000 213.000 135.000 ;
        RECT 38.000 133.000 213.000 134.000 ;
        RECT 39.000 132.000 213.000 133.000 ;
        RECT 40.000 131.000 213.000 132.000 ;
        RECT 41.000 130.000 213.000 131.000 ;
        RECT 42.000 129.000 213.000 130.000 ;
        RECT 43.000 127.000 213.000 129.000 ;
        RECT 44.000 126.000 213.000 127.000 ;
        RECT 45.000 125.000 213.000 126.000 ;
        RECT 46.000 124.000 213.000 125.000 ;
        RECT 47.000 123.000 213.000 124.000 ;
        RECT 48.000 122.000 213.000 123.000 ;
        RECT 49.000 121.000 213.000 122.000 ;
        RECT 50.000 120.000 213.000 121.000 ;
        RECT 51.000 119.000 213.000 120.000 ;
        RECT 52.000 118.000 213.000 119.000 ;
        RECT 53.000 117.000 213.000 118.000 ;
        RECT 54.000 116.000 213.000 117.000 ;
        RECT 55.000 115.000 213.000 116.000 ;
        RECT 56.000 114.000 213.000 115.000 ;
        RECT 57.000 113.000 213.000 114.000 ;
        RECT 58.000 112.000 213.000 113.000 ;
        RECT 59.000 111.000 213.000 112.000 ;
        RECT 60.000 109.000 213.000 111.000 ;
        RECT 61.000 108.000 213.000 109.000 ;
        RECT 62.000 107.000 213.000 108.000 ;
        RECT 63.000 106.000 213.000 107.000 ;
        RECT 64.000 105.000 213.000 106.000 ;
        RECT 65.000 104.000 213.000 105.000 ;
        RECT 66.000 103.000 213.000 104.000 ;
        RECT 67.000 102.000 213.000 103.000 ;
        RECT 68.000 101.000 213.000 102.000 ;
        RECT 69.000 100.000 213.000 101.000 ;
        RECT 70.000 99.000 213.000 100.000 ;
        RECT 71.000 98.000 213.000 99.000 ;
        RECT 72.000 97.000 213.000 98.000 ;
        RECT 73.000 96.000 213.000 97.000 ;
        RECT 74.000 95.000 213.000 96.000 ;
        RECT 75.000 94.000 213.000 95.000 ;
        RECT 76.000 93.000 213.000 94.000 ;
        RECT 77.000 92.000 213.000 93.000 ;
        RECT 78.000 91.000 213.000 92.000 ;
        RECT 79.000 90.000 213.000 91.000 ;
        RECT 80.000 89.000 213.000 90.000 ;
        RECT 81.000 87.000 213.000 89.000 ;
        RECT 82.000 86.000 213.000 87.000 ;
        RECT 83.000 85.000 213.000 86.000 ;
        RECT 84.000 84.000 213.000 85.000 ;
        RECT 85.000 83.000 213.000 84.000 ;
        RECT 86.000 82.000 213.000 83.000 ;
        RECT 87.000 81.000 213.000 82.000 ;
        RECT 88.000 80.000 213.000 81.000 ;
        RECT 89.000 79.000 213.000 80.000 ;
        RECT 90.000 78.000 213.000 79.000 ;
        RECT 91.000 77.000 213.000 78.000 ;
        RECT 92.000 76.000 213.000 77.000 ;
        RECT 93.000 75.000 213.000 76.000 ;
        RECT 94.000 74.000 213.000 75.000 ;
        RECT 95.000 73.000 213.000 74.000 ;
        RECT 96.000 72.000 213.000 73.000 ;
        RECT 97.000 71.000 213.000 72.000 ;
        RECT 98.000 70.000 213.000 71.000 ;
        RECT 99.000 69.000 213.000 70.000 ;
        RECT 100.000 68.000 213.000 69.000 ;
        RECT 101.000 67.000 213.000 68.000 ;
        RECT 102.000 66.000 213.000 67.000 ;
        RECT 103.000 65.000 213.000 66.000 ;
        RECT 104.000 64.000 213.000 65.000 ;
        RECT 105.000 63.000 213.000 64.000 ;
        RECT 106.000 62.000 213.000 63.000 ;
        RECT 107.000 61.000 213.000 62.000 ;
        RECT 108.000 60.000 213.000 61.000 ;
        RECT 109.000 59.000 213.000 60.000 ;
        RECT 110.000 57.000 213.000 59.000 ;
        RECT 111.000 56.000 213.000 57.000 ;
        RECT 112.000 55.000 213.000 56.000 ;
        RECT 113.000 54.000 213.000 55.000 ;
        RECT 114.000 53.000 213.000 54.000 ;
        RECT 115.000 52.000 213.000 53.000 ;
        RECT 116.000 51.000 213.000 52.000 ;
        RECT 117.000 50.000 213.000 51.000 ;
        RECT 118.000 49.000 213.000 50.000 ;
        RECT 119.000 48.000 213.000 49.000 ;
        RECT 120.000 47.000 213.000 48.000 ;
        RECT 121.000 46.000 213.000 47.000 ;
        RECT 122.000 45.000 213.000 46.000 ;
        RECT 123.000 44.000 213.000 45.000 ;
        RECT 124.000 43.000 213.000 44.000 ;
        RECT 125.000 42.000 213.000 43.000 ;
        RECT 126.000 41.000 213.000 42.000 ;
        RECT 127.000 39.000 213.000 41.000 ;
        RECT 128.000 38.000 213.000 39.000 ;
        RECT 129.000 37.000 213.000 38.000 ;
        RECT 130.000 36.000 213.000 37.000 ;
        RECT 131.000 35.000 213.000 36.000 ;
        RECT 132.000 34.000 213.000 35.000 ;
        RECT 133.000 33.000 213.000 34.000 ;
        RECT 134.000 32.000 213.000 33.000 ;
        RECT 135.000 31.000 213.000 32.000 ;
        RECT 136.000 30.000 213.000 31.000 ;
        RECT 137.000 29.000 213.000 30.000 ;
        RECT 138.000 28.000 213.000 29.000 ;
        RECT 139.000 27.000 213.000 28.000 ;
        RECT 140.000 26.000 213.000 27.000 ;
        RECT 141.000 25.000 213.000 26.000 ;
        RECT 142.000 24.000 213.000 25.000 ;
        RECT 143.000 23.000 213.000 24.000 ;
        RECT 144.000 22.000 213.000 23.000 ;
        RECT 145.000 21.000 213.000 22.000 ;
        RECT 146.000 19.000 213.000 21.000 ;
        RECT 147.000 18.000 213.000 19.000 ;
        RECT 148.000 17.000 213.000 18.000 ;
        RECT 149.000 16.000 213.000 17.000 ;
        RECT 150.000 15.000 213.000 16.000 ;
        RECT 151.000 14.000 213.000 15.000 ;
        RECT 153.000 13.000 213.000 14.000 ;
        RECT 154.000 12.000 213.000 13.000 ;
        RECT 155.000 11.000 213.000 12.000 ;
        RECT 156.000 10.000 213.000 11.000 ;
        RECT 157.000 9.000 213.000 10.000 ;
        RECT 158.000 8.000 213.000 9.000 ;
        RECT 159.000 7.000 213.000 8.000 ;
        RECT 160.000 6.000 213.000 7.000 ;
        RECT 161.000 5.000 213.000 6.000 ;
        RECT 162.000 4.495 213.000 5.000 ;
      LAYER Metal4 ;
        RECT 27.000 144.000 213.000 217.000 ;
        RECT 28.000 143.000 213.000 144.000 ;
        RECT 29.000 142.000 213.000 143.000 ;
        RECT 30.000 141.000 213.000 142.000 ;
        RECT 31.000 140.000 213.000 141.000 ;
        RECT 32.000 139.000 213.000 140.000 ;
        RECT 33.000 138.000 213.000 139.000 ;
        RECT 34.000 137.000 213.000 138.000 ;
        RECT 35.000 136.000 213.000 137.000 ;
        RECT 36.000 135.000 213.000 136.000 ;
        RECT 37.000 134.000 213.000 135.000 ;
        RECT 38.000 133.000 213.000 134.000 ;
        RECT 39.000 132.000 213.000 133.000 ;
        RECT 40.000 131.000 213.000 132.000 ;
        RECT 41.000 130.000 213.000 131.000 ;
        RECT 42.000 129.000 213.000 130.000 ;
        RECT 43.000 127.000 213.000 129.000 ;
        RECT 44.000 126.000 213.000 127.000 ;
        RECT 45.000 125.000 213.000 126.000 ;
        RECT 46.000 124.000 213.000 125.000 ;
        RECT 47.000 123.000 213.000 124.000 ;
        RECT 48.000 122.000 213.000 123.000 ;
        RECT 49.000 121.000 213.000 122.000 ;
        RECT 50.000 120.000 213.000 121.000 ;
        RECT 51.000 119.000 213.000 120.000 ;
        RECT 52.000 118.000 213.000 119.000 ;
        RECT 53.000 117.000 213.000 118.000 ;
        RECT 54.000 116.000 213.000 117.000 ;
        RECT 55.000 115.000 213.000 116.000 ;
        RECT 56.000 114.000 213.000 115.000 ;
        RECT 57.000 113.000 213.000 114.000 ;
        RECT 58.000 112.000 213.000 113.000 ;
        RECT 59.000 111.000 213.000 112.000 ;
        RECT 60.000 109.000 213.000 111.000 ;
        RECT 61.000 108.000 213.000 109.000 ;
        RECT 62.000 107.000 213.000 108.000 ;
        RECT 63.000 106.000 213.000 107.000 ;
        RECT 64.000 105.000 213.000 106.000 ;
        RECT 65.000 104.000 213.000 105.000 ;
        RECT 66.000 103.000 213.000 104.000 ;
        RECT 67.000 102.000 213.000 103.000 ;
        RECT 68.000 101.000 213.000 102.000 ;
        RECT 69.000 100.000 213.000 101.000 ;
        RECT 70.000 99.000 213.000 100.000 ;
        RECT 71.000 98.000 213.000 99.000 ;
        RECT 72.000 97.000 213.000 98.000 ;
        RECT 73.000 96.000 213.000 97.000 ;
        RECT 74.000 95.000 213.000 96.000 ;
        RECT 75.000 94.000 213.000 95.000 ;
        RECT 76.000 93.000 213.000 94.000 ;
        RECT 77.000 92.000 213.000 93.000 ;
        RECT 78.000 91.000 213.000 92.000 ;
        RECT 79.000 90.000 213.000 91.000 ;
        RECT 80.000 89.000 213.000 90.000 ;
        RECT 81.000 87.000 213.000 89.000 ;
        RECT 82.000 86.000 213.000 87.000 ;
        RECT 83.000 85.000 213.000 86.000 ;
        RECT 84.000 84.000 213.000 85.000 ;
        RECT 85.000 83.000 213.000 84.000 ;
        RECT 86.000 82.000 213.000 83.000 ;
        RECT 87.000 81.000 213.000 82.000 ;
        RECT 88.000 80.000 213.000 81.000 ;
        RECT 89.000 79.000 213.000 80.000 ;
        RECT 90.000 78.000 213.000 79.000 ;
        RECT 91.000 77.000 213.000 78.000 ;
        RECT 92.000 76.000 213.000 77.000 ;
        RECT 93.000 75.000 213.000 76.000 ;
        RECT 94.000 74.000 213.000 75.000 ;
        RECT 95.000 73.000 213.000 74.000 ;
        RECT 96.000 72.000 213.000 73.000 ;
        RECT 97.000 71.000 213.000 72.000 ;
        RECT 98.000 70.000 213.000 71.000 ;
        RECT 99.000 69.000 213.000 70.000 ;
        RECT 100.000 68.000 213.000 69.000 ;
        RECT 101.000 67.000 213.000 68.000 ;
        RECT 102.000 66.000 213.000 67.000 ;
        RECT 103.000 65.000 213.000 66.000 ;
        RECT 104.000 64.000 213.000 65.000 ;
        RECT 105.000 63.000 213.000 64.000 ;
        RECT 106.000 62.000 213.000 63.000 ;
        RECT 107.000 61.000 213.000 62.000 ;
        RECT 108.000 60.000 213.000 61.000 ;
        RECT 109.000 59.000 213.000 60.000 ;
        RECT 110.000 57.000 213.000 59.000 ;
        RECT 111.000 56.000 213.000 57.000 ;
        RECT 112.000 55.000 213.000 56.000 ;
        RECT 113.000 54.000 213.000 55.000 ;
        RECT 114.000 53.000 213.000 54.000 ;
        RECT 115.000 52.000 213.000 53.000 ;
        RECT 116.000 51.000 213.000 52.000 ;
        RECT 117.000 50.000 213.000 51.000 ;
        RECT 118.000 49.000 213.000 50.000 ;
        RECT 119.000 48.000 213.000 49.000 ;
        RECT 120.000 47.000 213.000 48.000 ;
        RECT 121.000 46.000 213.000 47.000 ;
        RECT 122.000 45.000 213.000 46.000 ;
        RECT 123.000 44.000 213.000 45.000 ;
        RECT 124.000 43.000 213.000 44.000 ;
        RECT 125.000 42.000 213.000 43.000 ;
        RECT 126.000 41.000 213.000 42.000 ;
        RECT 127.000 39.000 213.000 41.000 ;
        RECT 128.000 38.000 213.000 39.000 ;
        RECT 129.000 37.000 213.000 38.000 ;
        RECT 130.000 36.000 213.000 37.000 ;
        RECT 131.000 35.000 213.000 36.000 ;
        RECT 132.000 34.000 213.000 35.000 ;
        RECT 133.000 33.000 213.000 34.000 ;
        RECT 134.000 32.000 213.000 33.000 ;
        RECT 135.000 31.000 213.000 32.000 ;
        RECT 136.000 30.000 213.000 31.000 ;
        RECT 137.000 29.000 213.000 30.000 ;
        RECT 138.000 28.000 213.000 29.000 ;
        RECT 139.000 27.000 213.000 28.000 ;
        RECT 140.000 26.000 213.000 27.000 ;
        RECT 141.000 25.000 213.000 26.000 ;
        RECT 142.000 24.000 213.000 25.000 ;
        RECT 143.000 23.000 213.000 24.000 ;
        RECT 144.000 22.000 213.000 23.000 ;
        RECT 145.000 21.000 213.000 22.000 ;
        RECT 146.000 19.000 213.000 21.000 ;
        RECT 147.000 18.000 213.000 19.000 ;
        RECT 148.000 17.000 213.000 18.000 ;
        RECT 149.000 16.000 213.000 17.000 ;
        RECT 150.000 15.000 213.000 16.000 ;
        RECT 151.000 14.000 213.000 15.000 ;
        RECT 153.000 13.000 213.000 14.000 ;
        RECT 154.000 12.000 213.000 13.000 ;
        RECT 155.000 11.000 213.000 12.000 ;
        RECT 156.000 10.000 213.000 11.000 ;
        RECT 157.000 9.000 213.000 10.000 ;
        RECT 158.000 8.000 213.000 9.000 ;
        RECT 159.000 7.000 213.000 8.000 ;
        RECT 160.000 6.000 213.000 7.000 ;
        RECT 161.000 5.000 213.000 6.000 ;
        RECT 162.000 4.495 213.000 5.000 ;
      LAYER Metal5 ;
        RECT 27.000 144.000 213.000 217.000 ;
        RECT 28.000 143.000 213.000 144.000 ;
        RECT 29.000 142.000 213.000 143.000 ;
        RECT 30.000 141.000 213.000 142.000 ;
        RECT 31.000 140.000 213.000 141.000 ;
        RECT 32.000 139.000 213.000 140.000 ;
        RECT 33.000 138.000 213.000 139.000 ;
        RECT 34.000 137.000 213.000 138.000 ;
        RECT 35.000 136.000 213.000 137.000 ;
        RECT 36.000 135.000 213.000 136.000 ;
        RECT 37.000 134.000 213.000 135.000 ;
        RECT 38.000 133.000 213.000 134.000 ;
        RECT 39.000 132.000 213.000 133.000 ;
        RECT 40.000 131.000 213.000 132.000 ;
        RECT 41.000 130.000 213.000 131.000 ;
        RECT 42.000 129.000 213.000 130.000 ;
        RECT 43.000 127.000 213.000 129.000 ;
        RECT 44.000 126.000 213.000 127.000 ;
        RECT 45.000 125.000 213.000 126.000 ;
        RECT 46.000 124.000 213.000 125.000 ;
        RECT 47.000 123.000 213.000 124.000 ;
        RECT 48.000 122.000 213.000 123.000 ;
        RECT 49.000 121.000 213.000 122.000 ;
        RECT 50.000 120.000 213.000 121.000 ;
        RECT 51.000 119.000 213.000 120.000 ;
        RECT 52.000 118.000 213.000 119.000 ;
        RECT 53.000 117.000 213.000 118.000 ;
        RECT 54.000 116.000 213.000 117.000 ;
        RECT 55.000 115.000 213.000 116.000 ;
        RECT 56.000 114.000 213.000 115.000 ;
        RECT 57.000 113.000 213.000 114.000 ;
        RECT 58.000 112.000 213.000 113.000 ;
        RECT 59.000 111.000 213.000 112.000 ;
        RECT 60.000 109.000 213.000 111.000 ;
        RECT 61.000 108.000 213.000 109.000 ;
        RECT 62.000 107.000 213.000 108.000 ;
        RECT 63.000 106.000 213.000 107.000 ;
        RECT 64.000 105.000 213.000 106.000 ;
        RECT 65.000 104.000 213.000 105.000 ;
        RECT 66.000 103.000 213.000 104.000 ;
        RECT 67.000 102.000 213.000 103.000 ;
        RECT 68.000 101.000 213.000 102.000 ;
        RECT 69.000 100.000 213.000 101.000 ;
        RECT 70.000 99.000 213.000 100.000 ;
        RECT 71.000 98.000 213.000 99.000 ;
        RECT 72.000 97.000 213.000 98.000 ;
        RECT 73.000 96.000 213.000 97.000 ;
        RECT 74.000 95.000 213.000 96.000 ;
        RECT 75.000 94.000 213.000 95.000 ;
        RECT 76.000 93.000 213.000 94.000 ;
        RECT 77.000 92.000 213.000 93.000 ;
        RECT 78.000 91.000 213.000 92.000 ;
        RECT 79.000 90.000 213.000 91.000 ;
        RECT 80.000 89.000 213.000 90.000 ;
        RECT 81.000 87.000 213.000 89.000 ;
        RECT 82.000 86.000 213.000 87.000 ;
        RECT 83.000 85.000 213.000 86.000 ;
        RECT 84.000 84.000 213.000 85.000 ;
        RECT 85.000 83.000 213.000 84.000 ;
        RECT 86.000 82.000 213.000 83.000 ;
        RECT 87.000 81.000 213.000 82.000 ;
        RECT 88.000 80.000 213.000 81.000 ;
        RECT 89.000 79.000 213.000 80.000 ;
        RECT 90.000 78.000 213.000 79.000 ;
        RECT 91.000 77.000 213.000 78.000 ;
        RECT 92.000 76.000 213.000 77.000 ;
        RECT 93.000 75.000 213.000 76.000 ;
        RECT 94.000 74.000 213.000 75.000 ;
        RECT 95.000 73.000 213.000 74.000 ;
        RECT 96.000 72.000 213.000 73.000 ;
        RECT 97.000 71.000 213.000 72.000 ;
        RECT 98.000 70.000 213.000 71.000 ;
        RECT 99.000 69.000 213.000 70.000 ;
        RECT 100.000 68.000 213.000 69.000 ;
        RECT 101.000 67.000 213.000 68.000 ;
        RECT 102.000 66.000 213.000 67.000 ;
        RECT 103.000 65.000 213.000 66.000 ;
        RECT 104.000 64.000 213.000 65.000 ;
        RECT 105.000 63.000 213.000 64.000 ;
        RECT 106.000 62.000 213.000 63.000 ;
        RECT 107.000 61.000 213.000 62.000 ;
        RECT 108.000 60.000 213.000 61.000 ;
        RECT 109.000 59.000 213.000 60.000 ;
        RECT 110.000 57.000 213.000 59.000 ;
        RECT 111.000 56.000 213.000 57.000 ;
        RECT 112.000 55.000 213.000 56.000 ;
        RECT 113.000 54.000 213.000 55.000 ;
        RECT 114.000 53.000 213.000 54.000 ;
        RECT 115.000 52.000 213.000 53.000 ;
        RECT 116.000 51.000 213.000 52.000 ;
        RECT 117.000 50.000 213.000 51.000 ;
        RECT 118.000 49.000 213.000 50.000 ;
        RECT 119.000 48.000 213.000 49.000 ;
        RECT 120.000 47.000 213.000 48.000 ;
        RECT 121.000 46.000 213.000 47.000 ;
        RECT 122.000 45.000 213.000 46.000 ;
        RECT 123.000 44.000 213.000 45.000 ;
        RECT 124.000 43.000 213.000 44.000 ;
        RECT 125.000 42.000 213.000 43.000 ;
        RECT 126.000 41.000 213.000 42.000 ;
        RECT 127.000 39.000 213.000 41.000 ;
        RECT 128.000 38.000 213.000 39.000 ;
        RECT 129.000 37.000 213.000 38.000 ;
        RECT 130.000 36.000 213.000 37.000 ;
        RECT 131.000 35.000 213.000 36.000 ;
        RECT 132.000 34.000 213.000 35.000 ;
        RECT 133.000 33.000 213.000 34.000 ;
        RECT 134.000 32.000 213.000 33.000 ;
        RECT 135.000 31.000 213.000 32.000 ;
        RECT 136.000 30.000 213.000 31.000 ;
        RECT 137.000 29.000 213.000 30.000 ;
        RECT 138.000 28.000 213.000 29.000 ;
        RECT 139.000 27.000 213.000 28.000 ;
        RECT 140.000 26.000 213.000 27.000 ;
        RECT 141.000 25.000 213.000 26.000 ;
        RECT 142.000 24.000 213.000 25.000 ;
        RECT 143.000 23.000 213.000 24.000 ;
        RECT 144.000 22.000 213.000 23.000 ;
        RECT 145.000 21.000 213.000 22.000 ;
        RECT 146.000 19.000 213.000 21.000 ;
        RECT 147.000 18.000 213.000 19.000 ;
        RECT 148.000 17.000 213.000 18.000 ;
        RECT 149.000 16.000 213.000 17.000 ;
        RECT 150.000 15.000 213.000 16.000 ;
        RECT 151.000 14.000 213.000 15.000 ;
        RECT 153.000 13.000 213.000 14.000 ;
        RECT 154.000 12.000 213.000 13.000 ;
        RECT 155.000 11.000 213.000 12.000 ;
        RECT 156.000 10.000 213.000 11.000 ;
        RECT 157.000 9.000 213.000 10.000 ;
        RECT 158.000 8.000 213.000 9.000 ;
        RECT 159.000 7.000 213.000 8.000 ;
        RECT 160.000 6.000 213.000 7.000 ;
        RECT 161.000 5.000 213.000 6.000 ;
        RECT 162.000 4.495 213.000 5.000 ;
  END
END tt_logo_corner_tr
END LIBRARY

