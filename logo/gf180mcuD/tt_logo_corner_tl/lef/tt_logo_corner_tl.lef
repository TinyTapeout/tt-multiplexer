VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO tt_logo_corner_tl
  CLASS BLOCK ;
  FOREIGN tt_logo_corner_tl ;
  ORIGIN 0.000 0.000 ;
  SIZE 164.000 BY 164.000 ;
  OBS
      LAYER Metal1 ;
        RECT 64.000 162.000 100.000 164.000 ;
        RECT 48.000 157.000 116.000 162.000 ;
        RECT 39.000 152.000 125.000 157.000 ;
        RECT 32.000 147.000 132.000 152.000 ;
        RECT 26.000 142.000 138.000 147.000 ;
        RECT 21.000 137.000 143.000 142.000 ;
        RECT 17.000 132.000 147.000 137.000 ;
        RECT 13.000 127.000 151.000 132.000 ;
        RECT 10.000 122.000 154.000 127.000 ;
        RECT 7.000 117.000 157.000 122.000 ;
        RECT 5.000 112.000 159.000 117.000 ;
        RECT 3.000 107.000 161.000 112.000 ;
        RECT 2.000 102.000 162.000 107.000 ;
        RECT 1.000 97.000 163.000 102.000 ;
        RECT 0.000 67.000 164.000 97.000 ;
        RECT 1.000 62.000 163.000 67.000 ;
        RECT 2.000 57.000 162.000 62.000 ;
        RECT 3.000 52.000 161.000 57.000 ;
        RECT 5.000 47.000 159.000 52.000 ;
        RECT 7.000 42.000 157.000 47.000 ;
        RECT 10.000 37.000 154.000 42.000 ;
        RECT 13.000 32.000 151.000 37.000 ;
        RECT 17.000 27.000 147.000 32.000 ;
        RECT 21.000 22.000 143.000 27.000 ;
        RECT 26.000 17.000 138.000 22.000 ;
        RECT 32.000 12.000 132.000 17.000 ;
        RECT 39.000 7.000 125.000 12.000 ;
        RECT 48.000 2.000 116.000 7.000 ;
        RECT 64.000 0.000 100.000 2.000 ;
      LAYER Metal2 ;
        RECT 64.000 162.000 100.000 164.000 ;
        RECT 48.000 157.000 116.000 162.000 ;
        RECT 39.000 152.000 125.000 157.000 ;
        RECT 32.000 147.000 132.000 152.000 ;
        RECT 26.000 142.000 138.000 147.000 ;
        RECT 21.000 137.000 143.000 142.000 ;
        RECT 17.000 132.000 147.000 137.000 ;
        RECT 13.000 127.000 151.000 132.000 ;
        RECT 10.000 122.000 154.000 127.000 ;
        RECT 7.000 117.000 157.000 122.000 ;
        RECT 5.000 112.000 159.000 117.000 ;
        RECT 3.000 107.000 161.000 112.000 ;
        RECT 2.000 102.000 162.000 107.000 ;
        RECT 1.000 97.000 163.000 102.000 ;
        RECT 0.000 67.000 164.000 97.000 ;
        RECT 1.000 62.000 163.000 67.000 ;
        RECT 2.000 57.000 162.000 62.000 ;
        RECT 3.000 52.000 161.000 57.000 ;
        RECT 5.000 47.000 159.000 52.000 ;
        RECT 7.000 42.000 157.000 47.000 ;
        RECT 10.000 37.000 154.000 42.000 ;
        RECT 13.000 32.000 151.000 37.000 ;
        RECT 17.000 27.000 147.000 32.000 ;
        RECT 21.000 22.000 143.000 27.000 ;
        RECT 26.000 17.000 138.000 22.000 ;
        RECT 32.000 12.000 132.000 17.000 ;
        RECT 39.000 7.000 125.000 12.000 ;
        RECT 48.000 2.000 116.000 7.000 ;
        RECT 64.000 0.000 100.000 2.000 ;
      LAYER Metal3 ;
        RECT 64.000 162.000 100.000 164.000 ;
        RECT 48.000 157.000 116.000 162.000 ;
        RECT 39.000 152.000 125.000 157.000 ;
        RECT 32.000 147.000 132.000 152.000 ;
        RECT 26.000 142.000 138.000 147.000 ;
        RECT 21.000 137.000 143.000 142.000 ;
        RECT 17.000 132.000 147.000 137.000 ;
        RECT 13.000 127.000 151.000 132.000 ;
        RECT 10.000 122.000 154.000 127.000 ;
        RECT 7.000 117.000 157.000 122.000 ;
        RECT 5.000 112.000 159.000 117.000 ;
        RECT 3.000 107.000 161.000 112.000 ;
        RECT 2.000 102.000 162.000 107.000 ;
        RECT 1.000 97.000 163.000 102.000 ;
        RECT 0.000 67.000 164.000 97.000 ;
        RECT 1.000 62.000 163.000 67.000 ;
        RECT 2.000 57.000 162.000 62.000 ;
        RECT 3.000 52.000 161.000 57.000 ;
        RECT 5.000 47.000 159.000 52.000 ;
        RECT 7.000 42.000 157.000 47.000 ;
        RECT 10.000 37.000 154.000 42.000 ;
        RECT 13.000 32.000 151.000 37.000 ;
        RECT 17.000 27.000 147.000 32.000 ;
        RECT 21.000 22.000 143.000 27.000 ;
        RECT 26.000 17.000 138.000 22.000 ;
        RECT 32.000 12.000 132.000 17.000 ;
        RECT 39.000 7.000 125.000 12.000 ;
        RECT 48.000 2.000 116.000 7.000 ;
        RECT 64.000 0.000 100.000 2.000 ;
      LAYER Metal4 ;
        RECT 64.000 162.000 100.000 164.000 ;
        RECT 48.000 157.000 116.000 162.000 ;
        RECT 39.000 152.000 125.000 157.000 ;
        RECT 32.000 147.000 132.000 152.000 ;
        RECT 26.000 142.000 138.000 147.000 ;
        RECT 21.000 137.000 143.000 142.000 ;
        RECT 17.000 132.000 147.000 137.000 ;
        RECT 13.000 127.000 151.000 132.000 ;
        RECT 10.000 122.000 154.000 127.000 ;
        RECT 7.000 117.000 157.000 122.000 ;
        RECT 5.000 112.000 159.000 117.000 ;
        RECT 3.000 107.000 161.000 112.000 ;
        RECT 2.000 102.000 162.000 107.000 ;
        RECT 1.000 97.000 163.000 102.000 ;
        RECT 0.000 67.000 164.000 97.000 ;
        RECT 1.000 62.000 163.000 67.000 ;
        RECT 2.000 57.000 162.000 62.000 ;
        RECT 3.000 52.000 161.000 57.000 ;
        RECT 5.000 47.000 159.000 52.000 ;
        RECT 7.000 42.000 157.000 47.000 ;
        RECT 10.000 37.000 154.000 42.000 ;
        RECT 13.000 32.000 151.000 37.000 ;
        RECT 17.000 27.000 147.000 32.000 ;
        RECT 21.000 22.000 143.000 27.000 ;
        RECT 26.000 17.000 138.000 22.000 ;
        RECT 32.000 12.000 132.000 17.000 ;
        RECT 39.000 7.000 125.000 12.000 ;
        RECT 48.000 2.000 116.000 7.000 ;
        RECT 64.000 0.000 100.000 2.000 ;
      LAYER Metal5 ;
        RECT 64.000 162.000 100.000 164.000 ;
        RECT 48.000 157.000 116.000 162.000 ;
        RECT 39.000 152.000 125.000 157.000 ;
        RECT 32.000 147.000 132.000 152.000 ;
        RECT 26.000 142.000 138.000 147.000 ;
        RECT 21.000 137.000 143.000 142.000 ;
        RECT 17.000 132.000 147.000 137.000 ;
        RECT 13.000 127.000 151.000 132.000 ;
        RECT 10.000 122.000 154.000 127.000 ;
        RECT 7.000 117.000 157.000 122.000 ;
        RECT 5.000 112.000 159.000 117.000 ;
        RECT 3.000 107.000 161.000 112.000 ;
        RECT 2.000 102.000 162.000 107.000 ;
        RECT 1.000 97.000 163.000 102.000 ;
        RECT 0.000 67.000 164.000 97.000 ;
        RECT 1.000 62.000 163.000 67.000 ;
        RECT 2.000 57.000 162.000 62.000 ;
        RECT 3.000 52.000 161.000 57.000 ;
        RECT 5.000 47.000 159.000 52.000 ;
        RECT 7.000 42.000 157.000 47.000 ;
        RECT 10.000 37.000 154.000 42.000 ;
        RECT 13.000 32.000 151.000 37.000 ;
        RECT 17.000 27.000 147.000 32.000 ;
        RECT 21.000 22.000 143.000 27.000 ;
        RECT 26.000 17.000 138.000 22.000 ;
        RECT 32.000 12.000 132.000 17.000 ;
        RECT 39.000 7.000 125.000 12.000 ;
        RECT 48.000 2.000 116.000 7.000 ;
        RECT 64.000 0.000 100.000 2.000 ;
  END
END tt_logo_corner_tl
END LIBRARY

